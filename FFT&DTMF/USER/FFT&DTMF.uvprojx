# Keil uVision project FFT&DTMF.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FFT&DTMF +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\OLED;..\DSP_LIB;..\CORE;..\SYSTEM\findkey;..\HARDWARE\timer;..\HARDWARE\usart;..\SYSTEM\activityflag;..\SYSTEM\activity;..\SYSTEM\frespectrum
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/usart/: usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/findkey/: findkey.c
    ../SYSTEM/activity/: activity.c
    ../SYSTEM/frespectrum/: frespectrum.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group DSP_LIB
    ../DSP_LIB/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s stm32_dsp.h table_fft.h
